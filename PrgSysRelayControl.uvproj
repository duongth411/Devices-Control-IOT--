# Keil uVision project PrgSysRelayControl.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: PrgSysRelayControl +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\lib;.\Include
  group Main
    ./: main.c main.h
  group Common
    ./Common/: Common.c
  group Startup
    ./Startup/: STARTUP.A51
  group Header
    ./: glbvar.h port.h
  group lib
    ./lib/: def8051SoftI2c.c def8051DS1307.c def8051ADCread.c defDELAY16MHZ.c defLCD0802.c
